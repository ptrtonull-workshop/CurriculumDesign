# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code\hea
  group Source Group 1
    ./: STARTUP.A51
    ./code/src/: beep.c fire.c gas.c hc.c led.c main.c sim900a.c wifiReceive.c wifiSent.c delay.c
