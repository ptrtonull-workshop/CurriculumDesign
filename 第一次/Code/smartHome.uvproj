# Keil uVision project smartHome.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: smartHome +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\H
  group SmartHome
    ./: STARTUP.A51
    ./src/C/: beep.c fire.c gas.c hc.c led.c main.c sim900a.c
